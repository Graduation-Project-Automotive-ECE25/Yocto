FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://usercfg.txt"
SRC_URI += "file://cmdline.txt"
